# Keil uVision project dev_io.uvproj, settings and files
target Target 1 (MCS-51)
  device: EZ-USB FX2 (CY7C68XXX) Cypress Semiconductor
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) XRAM(0xE000-0xE1FF) CLOCK(48000000) MODDP2
  output: dev_io +hex
  AfterMake: ..\..\Bin\hex2bix -i -f 0xC2 -o dev_io.iic dev_io.hex
  c flags: Optimize=6 SizeSpeed=1
  group Source Group 1
    ./: dev_io.c LED_Key.c iic_comm.c ESP8266.c ssd1306.c MQTTPacket.c
    ../../Target/Lib/LP/: EZUSB.LIB
